# Repository Lukelectro/PowerNode

## KiCad design PoesPPowerNode.kicad_pcb

Parts:
C1: 100uF; CP_Radial_D6.3mm_P2.50mm; Farnell 8126240
C2: 100n_OPT; C_0805_2012Metric; Farnell 2522443
C3: C_2u2_OPT; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Farnell 2429358
C4, C9: 2u2; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Farnell 2429358
C5, C8, C10: 100n; C_0805_2012Metric; Farnell 2522443
D1: AARTLED; LED_D3.0mm
D2: bav99+; SOT-23; Farnell 2675152
D3: OPTIONAL1n4148; D_SOD-123F; Farnell 2675147
D4, D6, D8: LED; LED_D3.0mm
D5, D11: Zener_3v3; D_MELF-RM10_Universal_Handsoldering; Farnell 1861479
D7: 1n4148; D_SOD-123F; Farnell 2675147
F1: 0,1AT; Fuseholder_Cylinder-5x20mm_Schurter_0031_8201_Horizontal_Op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
H1, H2: hole2m2; MountingHole_2.2mm_M2
J1, J2, J4, J6: Screw_Terminal_1x02; TerminalBlock_RND_205-00232_1x02_P5.08mm_Horizontal
J3, J5: Screw_Terminal_1x03; TerminalBlock_RND_205-00288_1x03_P5.08mm_Horizontal
JP1, JP4: Jumper_NO_Small; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
JP2, JP3: Jumper_NC_Small; NC_Jumper_Pinheader
LOGO1: Logo_ESD; ESD-Logo_6.6x6mm_SilkScreen
LOGO2: Logo_MSL; LOGO_MSL_Silk
LOGO3: Logo_Kicad; KiCad-Logo_6mm_SilkScreen
LOGO4: Logo_AS; Logo_AS_Small
LOGO5: Logo_LJP; LJPVLOGO
MK1, MK2, MK3, MK4, MK5: Mounting_Hole; MountingHole_3.2mm_M3_DIN965
P1: CONN_01X25_POESP1.0; PinSocket_1x25_P2.54mm_Vertical
P2, P3, P5, P6, P8, P10, P11: CONN_01X02; PinHeader_1x02_P2.54mm_Vertical
P4: CONN_01X03; PinHeader_1x03_P2.54mm_Vertical
P7: CONN_01X08; PinHeader_1x08_P2.54mm_Vertical
P9: CONN_01X16; PinHeader_1x16_P2.54mm_Vertical
PS1: HiLink_HLK-PM01; Hi-Link_HLK_PM01
Q1, Q2: BC847; SOT-23
R1, R2, R10, R17, R20, R21, R24, R30, R31: 33k; R_0805_2012Metric
R3, R5, R15, R16: 2k2; R_0805_2012Metric
R4: 7k15; R_0805_2012Metric
R6, R7, R8, R9, R11, R12, R13, R14: 68k; R_1206_3216Metric; Farnell 2447536
R18, R25: 330R; R_0805_2012Metric
R19, R22: 10k; R_0805_2012Metric
R23: 50R 1%; R_0805_2012Metric; Farnell 2447669
RL1: FINDER-40.52; Relay_DPDT_Schrack-RT2-FormC_RM5mm
SW1, SW2: SW_Push; SW_PUSH_6mm_H13mm
TR1: ZMCT118F 1000:1; ZMCT118F_hybrid_2
U1, U2: VOS627; SSOP4_HP; Farnell 2547284
U3: LM35-LP; TO-92_Inline_Wide
U4: ESP32-WROOM
U6: NCP1117ST33T3G_MountingTab; SOT-223
U7: R-78E3.3-0.5; TO-220_Neutral123_PadsOnly; Farnell 2218602

Connections:
+3V3: C9.1, C10.2, D2.2 (K), P1.11, P3.2, P4.1, P5.1, P7.8, R1.2, R2.2, R15.2, R17.2, R20.2, R24.2, U4.2, U6.2 (VO), U6.4 (VO), U7.3 (out); also elsewhere on the board
+12P: C1.1, C8.1, JP2.1, P1.12, P6.1, PS1.4, U3.1 (+VS), U6.3 (VI), U7.1 (IN)
/AartTriac/LOAD_L: J4.2; also elsewhere on the board
/AartTriac/N: J4.1; also elsewhere on the board
/AartTriac/OPTO_INPUT: JP3.2; also elsewhere on the board
/EN: P1.4, U4.3
/IO2: C2.1, D5.1 (K), P1.21, R17.1, R18.2, U4.24
/IO4: P1.15, R5.2, U4.26
/IO5: P1.17, R16.2, U4.29
/IO12: P1.19, P7.4, U4.14
/IO13: P1.20, P7.3, U4.16
/IO14: P1.18, P7.2, U4.13
/IO15: C3.1, D2.3 (common), D3.1 (K), P1.22, P7.1, R19.1, U4.23
/IO16: P1.16, R3.2, U4.27
/IO32: P1.9, P7.7, U4.8
/IO33: P1.10, P7.5, U4.9
/IO34: P1.7, R1.1, U1.4, U4.6
/IO35: P1.8, R2.1, U2.4, U4.7
/I_36: P1.5, U3.2 (Vout), U4.4
/I_39: C5.1, D11.1 (K), P1.6, R24.1, R25.2, U4.5
/RX0: P1.3, U4.34
/SET_V++: P1.13, R4.2
/TX0: P1.2, U4.35
/VR0: P9.10, U4.25
/VR6: P9.3, U4.20
/VR7: P9.2, U4.21
/VR8: P9.1, U4.22
/VR9: P9.6, U4.17
/VR10: P9.5, U4.18
/VR11: P9.4, U4.19
/VR17: P9.11, U4.28
/VR18: P9.12, U4.30
/VR19: P9.13, U4.31
/VR21: P9.14, U4.33
/VR22: P9.15, U4.36
/VR23: P9.16, U4.37
/VR25: P9.9, U4.10
/VR26: P9.8, U4.11
/VR27: P9.7, U4.12
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C8.2, C9.2, C10.1, D1.1 (K), D2.1 (A), D5.2 (A), D8.1 (K), D11.2 (A), JP1.2, JP4.2, P1.1, P1.14, P4.3, P5.2, P6.2, P7.6, P8.2, PS1.3, Q1.3 (E), Q2.3 (E), R4.1, R21.1, R30.1, R31.1, SW1.2, SW2.2, U1.3, U2.3, U3.3 (GND), U4.1, U4.15, U4.38, U4.39, U6.1 (GND), U7.2 (GND)
unnamed: C4.1, P10.2, P11.2, R20.1, R21.2, R23.2, TR1.2
unnamed: D1.2 (A), R3.1
unnamed: D3.2 (A), R22.1
unnamed: D4.1 (K), D7.2 (A), JP4.1, P2.1, Q2.2 (C), RL1.A1
unnamed: D4.2 (A), R10.1
unnamed: D6.1 (K), JP1.1, JP3.1, P3.1, Q1.2 (C)
unnamed: D6.2 (A), R15.1
unnamed: D7.1 (K), JP2.2, P2.2, R10.2, RL1.A2
unnamed: D8.2 (A), P4.2, R18.1, SW1.1
unnamed: F1.1, PS1.1
unnamed: F1.2, J6.1
unnamed: J1.1, R11.1
unnamed: J1.2, R12.1
unnamed: J2.1, R13.1
unnamed: J2.2, R14.1
unnamed: J3.1, RL1.12
unnamed: J3.2, RL1.14
unnamed: J3.3, RL1.11
unnamed: J5.1, RL1.22
unnamed: J5.2, RL1.21
unnamed: J5.3, RL1.24
unnamed: J6.2, PS1.2
unnamed: P8.1, R25.1, SW2.1
unnamed: P10.1, P11.1, R19.2, R22.2, R23.1, TR1.1
unnamed: Q1.1 (B), R5.1, R30.2
unnamed: Q2.1 (B), R16.1, R31.2
unnamed: R6.2, U1.1
unnamed: R7.1, U1.2
unnamed: R8.2, U2.1
unnamed: R9.2, U2.2
unnamed: R6.1, R11.2
unnamed: R7.2, R12.2
unnamed: R8.1, R13.2
unnamed: R9.1, R14.2

Notes on the sheet:
POESP_PINOUT CONNECTOR
RFID_RC552 Connector
relais optioneel te bestukken, Type Schrack RTE24012 of equiv. Liggen er veel van op MSL...
OPTIONAL
PowerNode basis PCB voor poesp. *poesp op header (zodat deze vervangbaar is door compatible nieuwer bord) *RFID lezer zoals andere nodes *Relaisuitgang om contactor powernode te sturen *Aart_triac uitgang om contactor powernode te sturen Beiden met indicatieled en header voor extern aansluiten rela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
Bij weglaten temperatuursensor als externe ADC ingang te gebruiken voor andere sensor.
One_Wire/GPIO connector Door de pullup weg te laten en de serieweerstand te verhogen kan 5V input ook.
Het is een 30A CT, maar gebruiken voor 16Arms max pri. 16mArms sec. = 22.6mApp 22.6mA * 50R = 1130mVpp 3.3V/2=1.65V > 1.13V dus dat is goed. AMR 1.65/50=33mApp : 33App pri =23.3Arms
SET_V++ open: 5V 7k15: 12V GND: 24V
ADC1CH0 = GPI36 = SENSOR_VN
V++ Output / 12V input bij geen PoESP maar Vroom
3v3 output
Opto-inputs for 240/400VAC
P2, P3: Open collector uitgang voor b.v. externe AartTriac
VROOMIO
Een ESP32Vroom wil 500mA (datasheet spec't dat als minimum dat de voeding moet kunnen leveren) Dat wordt met een LM1117-3.3 veel dissipatie, zou uit 5V nét kunnen... R-78E3.3-0.5 switcher is beter, Farnell 2218602
BC847 (NPN) en 2n7002 (N-fet) zijn pin compatible!
1 connector, 1 soldeervlakjes met trekontlasting (2 gaten om draad door te vlechten)

Parts:
C6, C7: 10n_MAINS; C_Rect_L13.5mm_W4.0mm_P10.00mm_FKS3_FKP3_MKS4
D12: Q_TRIAC_AAG_BTA24-600BRWG; TO-220-3_Vertical; Farnell 1057284
R26: 330R; R_0805_2012Metric
R27, R28: 470R; R_1206_3216Metric; Farnell 2861948
R29: 39R; R_1206_3216Metric
U5: MOC3023M; DIP-6_W7.62mm

Connections:
+3V3: R26.1; also elsewhere on the board
/AartTriac/LOAD_L: D12.1 (A1), R28.1, R29.1; also elsewhere on the board
/AartTriac/N: C6.1, C7.1, D12.2 (A2); also elsewhere on the board
/AartTriac/OPTO_INPUT: U5.2; also elsewhere on the board
unnamed: C6.2, R27.1, R28.2
unnamed: C7.2, R29.2
unnamed: D12.3 (G), U5.6
unnamed: R26.2, U5.1
unnamed: R27.2, U5.4

Notes on the sheet:
(3.3-1.5)/0.005=360

Board: 2 copper layers, 88.0 x 115.0 mm, 99 parts (18 on the bottom side), 79 nets.

## Commit log

2018-10-21 Powernode basisboard v1.1 zoals er pcb's van gemaakt zijn. Zie ook https://wiki.makerspaceleiden.nl/mediawiki/index.php/Powernode_1.1
2018-11-03 git attributes because linguist thinks the .GML gerber is in Game Maker Language while it is a gerber file instead
